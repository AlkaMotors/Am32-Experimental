# Keil uVision project stm32f303cct6.uvprojx, settings and files
target stm32f303cct6 (6190000::V6.19::ARMCLANG)
  device: STM32F303CCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32f303cct6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=8000000,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,STM32F303xC
  c include: ..\Mcu\f303\Inc;..\Inc;..\Mcu\f303\Drivers\CMSIS\Include;..\Mcu\f303\Drivers\STM32F3xx_HAL_Driver\Inc;..\Mcu\f303\Drivers\CMSIS\Device\ST\STM32F3xx\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  scatter file: .\stm32f303cct6\stm32f303cct6.sct.sct
  group Startup
    ../Mcu/f303/Startup/: startup_stm32f303xc.s
  group src
    ../Src/: dshot.c firmwareversion.c functions.c main.c signal.c sounds.c
  group f303
    ../Mcu/f303/Src/: ADC.c comparator.c eeprom.c IO.c peripherals.c phaseouts.c serial_telemetry.c stm32f3xx_it.c system_stm32f3xx.c
  group Drivers/Src/STM32F3xx_HAL_Driver
    ../Mcu/f303/Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_adc.c stm32f3xx_ll_comp.c stm32f3xx_ll_crc.c stm32f3xx_ll_dac.c stm32f3xx_ll_dma.c stm32f3xx_ll_exti.c stm32f3xx_ll_fmc.c stm32f3xx_ll_gpio.c stm32f3xx_ll_hrtim.c stm32f3xx_ll_i2c.c stm32f3xx_ll_opamp.c stm32f3xx_ll_pwr.c stm32f3xx_ll_rcc.c stm32f3xx_ll_rtc.c stm32f3xx_ll_spi.c stm32f3xx_ll_tim.c stm32f3xx_ll_usart.c stm32f3xx_ll_usb.c stm32f3xx_ll_utils.c
software components: CMSIS:CORE 5.6.0
